# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4,ARM_MATH_ROUNDING,__FPU_PRESENT
  c misc: --diag_suppress=2803,1,1035
  c include: .\source\third_party\CMSIS\Include;.\source;.\Hardware;.\User;.\source\ti\devices\msp432e4\inc;.\Source\ti\devices\msp432e4\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group source
    ./source/: startup_msp432e401y_uvision.s system_msp432e401y.c
  group Libarary
    ./Libarary/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h driverlib.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h onewire.c onewire.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h types.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group Hardware
    ./Hardware/: ADC_u.c ADC_u.h SPI_u.c SPI_u.h TIM_u.c TIM_u.h Uart.c Uart.h AD9833.c AD9833.h
  group User
    ./User/: main.c system_init.c system_init.h delay.c delay.h arm_common_tables.h arm_const_structs.h arm_cortexM4l_math.lib arm_math.h fft.c fft.h hamming_1024.h hamming_1024.c
